## boards/training/board.yml
```yaml
board:
  name: training
  full_name: Training Board
  vendor: acme
  socs:
    - name: mcxn947
```
